# Keil uVision project DoCD.uvproj, settings and files
target DoCD (MCS-51)
  device: DQ8051 Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000)
  output: ir +hex
  AfterMake: D:\8051_I2C\8051_normal_code\srec_cat.exe ir.hex -Intel -byte-swap 4 -fill 0xff 0 4096 -o ir.bin -Binary
  group Source
    ./: docd.c Int_Vec.c SunReg.c i2c_slave_common.c diag.c rbus.c i2c_slave.c
  group H
    ./: docd.h DP8051XP.H Int_Vec.h proto.h SunReg.H
  group ASM
    ./: startup.a51
